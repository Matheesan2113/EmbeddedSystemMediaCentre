# Keil uVision project Blinky.uvproj, settings and files
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=4 oTime=1
  c misc: --diag_suppress 550
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: GLCD_SPI_LPC1700.c LED.c IRQ.c Blinky.c KBD.c KBD.h game.c game.h adcuser.c usbcore.c usbdesc.c usbdmain.c usbhw.c usbuser.c TTT.c ADC.c
  group Pictures
    ./: goku.c music.c sasuke.c kakashi.c
  group Documentation
    ./: Abstract.txt
  group Core Code
    ./: core_cm3.c
